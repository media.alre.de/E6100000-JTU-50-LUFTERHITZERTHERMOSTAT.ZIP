Properties of the parts of a building model (IFC4)

# File
Description: Kanal-Thermostat, -25…+65 °C, Hysterese 1,5K, Kapillarlänge 350 mm, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6100000, Kanal-Thermostat, -25…+65 °C, Hysterese 1,5K, Kapillarlänge 350 mm
In: Raum
Description: Minimal- oder Maximalthermostat zur Zuluftüberwachung und Ventilatorregelung in Lüftungs- und Klimaanlagen. Überhitzungsschutzthermostat für elektrische Heizregister und direkt befeuerte Lufterhitzer im Öl- und Gasbetrieb.; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6100000; ModelLabel: JTU-50; GlobalTradeItemNumber: 4050528030672; ProductURL: https://alre.de/produkt_E6100000
Pset_Specification - NominalLength: 0.139 m; NominalWidth: 0.083 m; NominalDepth: 0.058 m; NetWeight: 0.761
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 80; Ausführung des Sensors: Kapillarrohr; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP40; Elektronische Ausführung: no; Geeignet als Wächter: yes; Mediumtemperatur: -15; Schaltdifferenz der Temperatur: 1.5; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6100000.pdf
